;MULTIPLICADOR 
		PROCESSOR 16F887
		INCLUDE P16F887.INC
CONT	EQU 020
X		EQU 021
Y		EQU 022
RESU	EQU 023
	ORG 0
	CLRF RESU
	CLRF CONT
	MOVLW .4
	MOVWF X
	MOVLW .10
	MOVWF Y
MULT INCF CONT,F
	MOVF X,W
	BTFSC Y,0
	ADDWF RESU, F
	RRF Y,F
	BCF STATUS,C
	RLF X,F
	MOVF CONT,W
	XORLW .4
	BTFSS STATUS, Z
	GOTO MULT
	NOP
END